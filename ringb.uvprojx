# Keil uVision project ringb.uvprojx, settings and files
target nrf51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ringb +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c include: .\Include;.\Include\app_common;.\Include\ble;.\Include\ble\ble_services;.\Include\ble\device_manager;.\Include\s110;.\Include\sd_common;.\Include\sdk;.\Include\app
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Services
    ./src/services/: ble_bas.c ble_dis.c ble_hrs.c
  group App
    ./src/app/: battery.c led.c main.c
  group Libraries
    ./src/libraries/: app_button.c app_gpiote.c app_timer.c app_trace.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c ble_error_log.c ble_srv_common.c crc16.c device_manager_peripheral.c pstorage.c simple_uart.c softdevice_handler.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
